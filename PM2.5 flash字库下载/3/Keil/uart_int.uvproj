# Keil uVision project uart_int.uvproj, settings and files
target LPC1700 FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: uart_int +hex
  c flags: Optim=1 wLevel=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0
  c include: ..\Core\CM3\CoreSupport;..\Core\CM3\DeviceSupport\NXP\LPC17xx;..\Drivers\include;..\..\time;..\app\include;..\..\最终GPS模板
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group CMSIS-CM3
    ../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ../Core/CM3/CoreSupport/: core_cm3.c
  group Drivers
    ../Drivers/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group Main
    ../: main.c
  group Readme
    ../: abstract.txt
  group app
    ../app/: GPS.C UART.C SPI.c zk.c
target LPC1700 RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: uart_int
  c flags: Optim=1 wLevel=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=1
  c include: ..\..\..\..\Core\CM3\CoreSupport;..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx;..\..\..\..\Drivers\include;..\..\Interrupt
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
