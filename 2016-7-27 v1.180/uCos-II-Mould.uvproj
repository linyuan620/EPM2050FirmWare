# Keil uVision project uCos-II-Mould.uvproj, settings and files
target LPC1700 FLASH (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC17xx-uCos-II-Mould +hex
  c flags: Optim=1 wLevel=2
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0,CH320
  c include: .\Core\CM3\CoreSupport;.\Core\CM3\DeviceSupport\NXP\LPC17xx;.\Drivers\include;.\uC-CPU;.\uC-CPU\ARM-Cortex-M3\RealView;.\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;.\uCOS-II\Source;.\uC-LIB;.\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\App;.\Modbus\modbus\include;.\Modbus\modbus\rtu;.\Modbus\port;.\Modbus\modbus\ascii;.\Modbus\modbus\tcp;.\Modbus\modbus\functions;.\MBDriver;.\MBDriver\master
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./Core/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group CMSIS-CM3
    ./Core/CM3/CoreSupport/: core_cm3.c
    ./Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Drivers
    ./Drivers/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group uC-CPU
    ./uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uC-OS-II/Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Port
    ./uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-LIB
    ./uC-LIB/: lib_str.c lib_mem.c
    ./uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group App
    ./App/: main.c uarts.c times.c dio.c i2c.c public.c init.c zk.c key.c picture.c rtc.c lcd.c menu.c FPGA_Contorl.c SPI.c Modbus.c Measure.c TCPIP.C store.c keyShow.c DTU.c SHELL.c Retarget.c
  group Readme
    ./: abstract.txt zlgmodbus移植记录.txt modubs网口.txt
  group zlgmodbus
    ./MBDriver/: MB_RTU.c MBCommon.c SYSHAL.C
    ./MBDriver/master/: OSFUNfile.c MB_MFunction.c MBMaster.c
    ./App/: output.c
  group freemodbus
    ./Modbus/modbus/: mb.c
    ./Modbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./Modbus/modbus/tcp/: mbtcp.c
    ./Modbus/port/: porttcp.c porttimer.c port.c portevent.c portserial.c
    ./Modbus/modbus/rtu/: mbrtu.c mbcrc.c
